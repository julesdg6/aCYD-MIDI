# Repository julesdg6/aCYD-MIDI

File README.md (part):

# aCYD MIDI Controller

Touchscreen Bluetooth MIDI controller for ESP32-based displays including the ESP32-2432S028R "Cheap Yellow Display" (CYD) and ESP32-4832S035 series.

[/badge.svg)](https://github.com/julesdg6/aCYD-MIDI/actions)

Special thanks to Brian Lough for putting together the resources on this board. Check out his repo for more examples: https://github.com/witnessmenow/ESP32-Cheap-Yellow-Display

This project was based on and heavily inspired by NickCulbertson/CYD-MIDI-Controller — thank you to Nick Culbertson for the original implementation and design decisions that informed this work. See the original repository: https://github.com/NickCulbertson/CYD-MIDI-Controller

## Quick Start

**Download pre-built firmware:** Check the [Releases](https://github.com/julesdg6/aCYD-MIDI/releases) page for ready-to-flash `.bin` files for your board configuration.

**GitHub Pages:** Visit the [web installer](https://julesdg6.github.io/aCYD-MIDI/) for easy firmware flashing, or use the [debug console](https://julesdg6.github.io/aCYD-MIDI/debug-console/) for testing and troubleshooting.

**Web Debug Console:** Try the [online debugging tool](https://julesdg6.github.io/aCYD-MIDI/debug-console/) to test MIDI and monitor device logs via Web Bluetooth and Web Serial (Chrome/Edge required).

## Features

See [`docs/README.md`](docs/README.md) for module deep-dives, capture flow, and Wi-Fi notes.

### 18+ Interactive Modes

- **KEYS** - Virtual piano keyboard with scale and key controls
- **BEATS** - 16-step sequencer with 4 tracks and tempo control
- **BABY8** (Optional) - 8-step sequencer emulation with virtual encoders, per-step note/velocity/gate, pattern storage, tempo, and swing controls ([docs/BABY8_EMULATION.md](docs/BABY8_EMULATION.md))
- **ZEN** - Ambient bouncing ball mode for generative music
- **DROP** - Physics-based ball drop with customizable platforms
- **RNG** - Random music generator for creative exploration
- **XY PAD** - Touch-controlled X/Y pad for real-time parameter control
- **ARP** - Arpeggiator with chord-based patterns
- **GRID** - Grid piano with 4ths layout for unique playing style
- **CHORD** - Auto-chord mode with diatonic chord progressions
- **LFO** - Low-frequency oscillator for modulation effects
- **TB3PO** - TB-3 inspired generator with density, accent, and regen controls for rapid phrase creation
- **GRIDS** - Multi-layer arpeggiator blending kick/snare/hat densities with touch-based XY tweaking
- **RAGA** - Indian raga explorer with 2nd-order Markov chain music generation for Raga Bhairavi (captures authentic phrases and oscillations), scale selection, drone toggles, and tempo-aware dronescapes ([docs/RAGA_MODE_MARKOV_CHAIN.md](docs/RAGA_MODE_MARKOV_CHAIN.md))
- **EUCLID** - Euclidean rhythm sequencer with 8 voices, per-voice patterns, BPM, triplet toggles, and optional M5Stack 8Encoder hardware support for hands-on control
- **MORPH** - Gesture morphing surface that blends stored slots, X/Y sliders, and rec/play controls
- **SLINK** - Dual-wave generative engine with 16-band triggering, tabbed parameter panels, and MIDI scale/clock modulation for evolving textures ([docs/SLINK_IMPLEMENTATION.md](docs/SLINK_IMPLEMENTATION.md))
- **DIMENSIONS** - Parametric sequencer using mathematical equations to generate MIDI patterns - 20 equations with A/B/C/D parameters for creating evolving, non-obvious melodies and rhythms (ported from [ErikOostveen/Dimensions](https://github.com/ErikOostveen/Dimensions))
- **SLOTS** - Slot-based multi-sequencer with global transport, per-slot mute/channel assignment, and quantized looper recording (experimental menu)
- **KPNUM** - Zynthian v5 keypad emulator (kpnum_jofe-inspired) with a 5x4 touch pad, menu/navigation actions, and play/record transport toggles (experimental menu)

### Core Features

- **Bluetooth MIDI** - Wireless connection to DAWs and music software
- **USB MIDI** - Native USB MIDI device for ESP32-S3 headless builds (PC/Mac/Android/iOS compatible, no drivers needed) ([docs/HEADLESS_USB_MIDI.md](docs/HEADLESS_USB_MIDI.md))
- **ESP-NOW MIDI** - Low-latency wireless MIDI networking between multiple CYD devices without pairing (<10ms latency, auto-discovery, MIDI clock sync) ([docs/ESP_NOW_MIDI.md](docs/ESP_NOW_MIDI.md))
- **Hardware MIDI** - Dual BLE + DIN-5 output with selectable UART0 (production) or UART2 (development), conditional debug, and wiring/build guidance ([docs/HARDWARE_MIDI.md](docs/HARDWARE_MIDI.md), [docs/HARDWARE_MIDI_CONFIG.md](docs/HARDWARE_MIDI_CONFIG.md))
- **Touchscreen Interface** - Intuitive visual controls optimized for the CYD display
- **Real-time Control** - Low-latency MIDI output
- **Visual Feedback** - Responsive graphics
- **Screenshot Capture** - LVGL snapshot → BMP writer uses incremental filenames and padding-safe rows for consistent SD output
- **Main Menu** - 4×4 grid, darker rainbow palette, and black button labels align with the updated mockup in `assets/screenshots/00_main_menu.bmp`
- **Splash Screen** - Boot artwork now pulls `assets/aCYD-MIDI.png` and prints the connected IP when Wi-Fi is up
- **Remote Display** - WebSocket viewer with 20 FPS frames, auto-reconnect, and status indicator for browser monitoring ([docs/REMOTE_DISPLAY.md](docs/REMOTE_DISPLAY.md))
- **M5Stack 8Encoder Support** (Optional) - Hardware encoder expansion for hands-on parameter control with 8 rotary encoders and buttons, MIDI CC mapping, and persistent storage ([docs/M5STACK_8ENCODER.md](docs/M5STACK_8ENCODER.md))

## What You Need

### Supported Hardware

- **ESP32-2432S028R (CYD)** - 2.8" 320x240 display - ~$15 from AliExpress/Amazon
- **ESP32-4832S035C** - 3.5" 480x320 display with capacitive touch
- **ESP32-4832S035R** - 3.5" 480x320 display with resistive touch
- **ESP32-4832S040R** - 4.0" 480x320 display with resistive touch
- **Elecrow ESP32 7.0"** - 7.0" 800x480 display with capacitive touch ([product page](https://www.elecrow.com/wiki/esp32-display-702727-intelligent-touch-screen-wi-fi26ble-800480-hmi-display.html))
- **ESP32-S3 Dongles** - Headless USB MIDI mode (no display) with native USB MIDI support ([docs/HEADLESS_USB_MIDI.md](docs/HEADLESS_USB_MIDI.md))
- PlatformIO or Arduino IDE with ESP32 support
- *Optional:* Hardware MIDI circuit components (see [docs/HARDWARE_MIDI.md](docs/HARDWARE_MIDI.md))
- *Optional:* M5Stack 8Encoder Unit for hardware parameter control (see [docs/M5STACK_8ENCODER.md](docs/M5STACK_8ENCODER.md))
- **MicroSD Card** (optional) - For screenshot capture feature
- Arduino IDE with ESP32 support or PlatformIO

## Installation

### Option A: Web Installer (Easiest - No Software Required!)

Flash firmware directly from your browser using ESP Web Tools:

1. **Visit the Web Installer**: [https://julesdg6.github.io/aCYD-MIDI/](https://julesdg6.github.io/aCYD-MIDI/)

2. **Requirements:**
   - Chrome, Edge, or Opera browser (Web Serial API support)
   - USB cable to connect your ESP32 to your computer
   - ESP32 USB drivers (usually auto-installed)

3. **Flash Process:**
   - Connect your ESP32 board via USB
   - Click the "Install" button for your board model
   - Select your device's USB port when prompted
   - Wait for flashing to complete (1-2 minutes)

4. **Connect via Bluetooth**
   - Device will restart automatically
   - Pair "CYD MIDI" via Bluetooth
   - Select as MIDI input in your DAW
   - **Windows 11 users:** See [Platform-Specific Setup](#platform-specific-setup) for required software

**Supported boards:** All ESP32-2432S028R, ESP32-4832S035C/R, ESP32-4832S040R variants, and headless builds.

### Option B: Flash Pre-built Firmware (Command Line)

1. **Download firmware** from the [Releases](https://github.com/julesdg6/aCYD-MIDI/releases) page
   - Choose the appropriate `.bin` file for your board:
     
     **ESP32-2432S028R (CYD):**
     - `firmware-esp32-2432S028Rv2` - Default (UART2 for development with debug)
     - `firmware-esp32-2432S028Rv2-uart0` - Production (UART0 for hardware MIDI, no debug)
     - `firmware-esp32-2432S028Rv2-uart2` - Explicit UART2 configuration
     
     **ESP32-4832S035C (Capacitive Touch):**
     - `firmware-esp32-4832S035C` - Default (UART2 for development with debug)
     - `firmware-esp32-4832S035C-uart0` - Production (UART0 for hardware MIDI, no debug)
     - `firmware-esp32-4832S035C-uart2` - Explicit UART2 configuration
     
     **ESP32-4832S035R (Resistive Touch):**
     - `firmware-esp32-4832S035R` - Default (UART2 for development with debug)
     - `firmware-esp32-4832S035R-uart0` - Production (UART0 for hardware MIDI, no debug)
     - `firmware-esp32-4832S035R-uart2` - Explicit UART2 configuration
     
     **ESP32-4832S040R (4.0" Resistive Touch):**
     - `firmware-esp32-4832S040R` - Default (UART2 for development with debug)
     - `firmware-esp32-4832S040R-uart0` - Production (UART0 for hardware MIDI, no debug)
     - `firmware-esp32-4832S040R-uart2` - Explicit UART2 configuration
     
     **Elecrow ESP32 7.0" (7.0" Capacitive Touch):**
     - `firmware-elecrow-esp32-7_0` - Default (UART2 for development with debug)
     - `firmware-elecrow-esp32-7_0-uart0` - Production (UART0 for hardware MIDI, no debug)
     - `firmware-elecrow-esp32-7_0-uart2` - Explicit UART2 configuration
     
     **Headless USB MIDI:**
     - `firmware-esp32-headless-midi-master` - ESP32 headless (BLE + Hardware MIDI + ESP-NOW master, **no USB MIDI**)
     - `firmware-esp32s3-headless` - ESP32-S3 headless USB MIDI dongle (native USB MIDI + BLE + Hardware MIDI + ESP-NOW master)

2. **Flash using ESP32 Flash Tool** or **esptool.py**:
   ```bash
   esptool.py --chip esp32 --port /dev/ttyUSB0 write_flash 0x10000 firmware.bin
   ```

3. **Connect via Bluetooth**
   - Pair "CYD MIDI" via Bluetooth
   - Select as MIDI input in your DAW
   - **Windows 11 users:** See [Platform-Specific Setup](#platform-specific-setup) for required software

### Option C: Build from Source

#### Using PlatformIO (Recommended)

1. Install PlatformIO
2. Clone this repository
3. Build and upload for your board:
   ```bash
   # For ESP32-2432S028R (CYD)
   pio run -e esp32-2432S028Rv2 -t upload
   
   # For ESP32-4832S035C (Capacitive Touch)
   pio run -e esp32-4832S035C -t upload
   
   # For ESP32-4832S035R (Resistive Touch)
   pio run -e esp32-4832S035R -t upload
   
   # For ESP32-4832S040R (4.0" Resistive Touch)
   pio run -e esp32-4832S040R -t upload
   
   # For Elecrow ESP32 7.0" (7.0" Capacitive Touch)
   pio run -e elecrow-esp32-7_0 -t upload
   
   # For Headless ESP32 USB MIDI
   pio run -e esp32-headless-midi-master -t upload
   
   # For Headless ESP32-S3 USB MIDI dongle
   pio run -e esp32s3-headless -t upload
   ```

#### Using Arduino IDE

### 1. Add ESP32 Board Support
1. Go to `File` → `Preferences`
2. Add to "Additional Boards Manager URLs":
   ```
   https://espressif.github.io/arduino-esp32/package_esp32_index.json
   ```
3. Go to `Tools` → `Board` → `Boards Manager`
4. Search "ESP32" and install "ESP32 by Espressif Systems"

### 2. Install Libraries
In Arduino IDE Library Manager, install:
- `TFT_eSPI` by Bodmer
- `XPT2046_Touchscreen` by Paul Stoffregen

### 3. Configure TFT_eSPI
Replace the `libraries/TFT_eSPI/User_Setup.h` with the `User_Setup.h` from the repo.

### 4. Upload Code
1. Clone this repo and open `CYD_MIDI_Controller.ino`
2. Select board: `ESP32 Dev Module`
3. Connect CYD and upload
(Lower Upload Speed to `115200` if the sketch isn't uploading)

### 5. Connect
1. Pair "CYD MIDI" via Bluetooth
2. Select as MIDI input in your DAW
3. **Windows 11 users:** See [Platform-Specific Setup](#platform-specific-setup) for required software

## Display Autoscaling

The UI automatically scales to different screen sizes and resolutions. The system:

- **Auto-detects** display dimensions at startup from LVGL
- **Scales** all UI elements proportionally using scaling macros
- **Maintains** consistent layout across different ESP32/CYD hardware
- **Supports** custom display configurations via `platformio.ini`

### Reference Display
The default layout is designed for 320x240 pixels (ESP32-2432S028R). The scaling system automatically adjusts all coordinates, sizes, and spacing for different resolutions.

### Adding Support for New Displays
1. Configure your display hardware in `platformio.ini` build flags
2. The autoscaling system will automatically adjust the UI
3. No code changes needed - scaling happens at runtime
### 6. Optional: Hardware MIDI Output
For traditional DIN-5 MIDI output with lower latency, see the complete guide:
- **[Hardware MIDI Setup Guide](docs/HARDWARE_MIDI.md)**
- Supports simultaneous BLE + Hardware MIDI
- Two UART options: UART0 (serial breakout) or UART2 (expansion GPIOs)
- Circuit components ~$5-10

## Platform-Specific Setup

### Windows 11 BLE-MIDI Connection

Windows 11 requires additional software to connect to BLE-MIDI devices. Follow these steps to use your aCYD-MIDI controller with Windows:

**Requirements:**
- [BLE-MIDI Connect](https://apps.microsoft.com/detail/9NVMLZTTWWVL) (Microsoft Store)
- [loopMIDI](https://www.tobias-erichsen.de/software/loopmidi.html) by Tobias Erichsen

**Setup Steps:**

1. **Install and configure loopMIDI**
   - Download and install loopMIDI from [https://www.tobias-erichsen.de/software/loopmidi.html](https://www.tobias-erichsen.de/software/loopmidi.html)
   - Open the loopMIDI application
   - Create a new virtual MIDI port by clicking the `+` button
   - Name it something like "aCYD MIDI In"
   - This virtual port will act as the MIDI interface your DAW can see

2. **Install and configure BLE-MIDI Connect**
   - Install BLE-MIDI Connect from the [Microsoft Store](https://apps.microsoft.com/detail/9NVMLZTTWWVL)
   - Launch the app
   - Scan for your BLE-MIDI device (it should appear as "CYD MIDI")
   - Connect to the device
   - In the app's routing settings, select your loopMIDI port ("aCYD MIDI In") as the output
   - BLE-MIDI Connect now translates the Bluetooth MIDI stream into a standard Windows MIDI port

3. **Use the virtual port in your DAW**
   - Open your DAW or MIDI-capable software
   - Look for the loopMIDI port you created ("aCYD MIDI In")
   - Enable it as a MIDI input device

**Troubleshooting:**
- Make sure both loopMIDI and BLE-MIDI Connect are running before opening your DAW
- If the device doesn't appear, try restarting the BLE-MIDI Connect app
- Ensure your aCYD-MIDI device is powered on and in Bluetooth pairing mode

### macOS BLE-MIDI Connection

macOS has native BLE-MIDI support:

1. Open **Audio MIDI Setup** (Applications → Utilities → Audio MIDI Setup)
2. Click the Bluetooth MIDI icon in the toolbar
3. Select "CYD MIDI" from the list of available devices
4. The device will now appear as a MIDI input in your DAW

### Linux BLE-MIDI Connection

Linux users can use [bluez-alsa](https://github.com/Arkq/bluez-alsa) or [BLEMidi](https://github.com/oxesoft/blemidi) for BLE-MIDI connectivity. Specific setup varies by distribution.

## Usage

### Basic Operation
1. Power on the CYD - you'll see the splash screen
2. Pair "CYD MIDI" via Bluetooth on your device
3. Select as MIDI input in your DAW
4. Tap a mode from the main menu to start playing

### Taking Screenshots
1. Insert a MicroSD card (FAT16/FAT32 formatted) into the CYD's SD card slot
2. From the Settings screen, tap "Capture All Screens" button (or hold the Settings cog icon on main menu for ~1.5s)
3. The device will automatically:
   - Navigate through all modes and screens
   - Capture screenshots with 5-second delays between each
   - Save screenshots as BMP files to `/screenshots/` folder
   - Scroll through Settings menu sections if content extends beyond one screen
   - Capture all tabs/pages for multi-screen modes (SLINK: 7 tabs, WAAAVE: 3 pages, ENCODER_PANEL: 3 pages)
   - Generate a `documentation.txt` file listing all screenshots with descriptions
4. Files are named: `<board>-<version>_<mode>_NNN.bmp` (e.g., `esp32-2432S028Rv2-0-1-6_menu_000.bmp`)
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
## EAGLE design tmp/elecrow/extracted/DIS08070H-V2.0-20231204.brd

Parts:
C1: 0.1uF/NC; DISCRETE_C0603
C2, C4, C13, C20, C22, C24, C33, C50: 100nF; C0603
C3, C6, C8, C15, C18, C36, C44: 1uF; 0603
C5: 1uF; C0603
C7, C10, C19, C23, C37, C42, C43, C46: 22uF; 0805
C9, C17, C21, C26, C34, C35, C45: 100nF; 0603
C11: 4.7uF; 0603
C12, C29, C30: 1uF; DISCRETE_C0603
C14, C16: 1nF; C0603
C25, C32: 47uF; 0805
C27, C28: 100NF; 0603
C31: 10uF; DISCRETE_C0603
C38, C39: 10uF; C0603
C40, C41: 1uF; 0805
C47, C48, C49: 10uF; 0805_S
C51: 4.7uF/NC; 0603
C54: 4.7uF; DISCRETE_C0603
D1, D6: SS24B/SMB; 214AB
D2: BZT52C-18V; DISCRETE_SOD123
D3: SS24/SMB; 214AB
D4: BZT52C-8.2V; DISCRETE_SOD123
D5: IN5817; DO-214AC
J1, J5: PH2.0WT-2PIN
J2: 7.0-DIANRONG-50PIN-0.5MM; 7.0-DAINRONG-50PIN-0.5MM
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J4: 2.54-8PIN-WOTIE; 2.54-8P-WOTIE
J6, J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
K1, K4: BUTTON; 157SW
L1, L2, L4: L-0530; CD54_CD54
L5: CD32_6.8uH; CD32
LED1: RED; DISCRETE_LED-0603
P2, P4: FPC-6PIN-0.5MM
Q1, Q2: BAT54S; SOT23-3
Q3, Q4, Q30: PMOS-3401-4A; SOT-23
Q5, Q6: S8050; SPARKFUN_SOT23
Q9, Q10: S9013; SOT23@1
R1: 75K; DISCRETE_R0603
R2: 10.5K; DISCRETE_R0603
R3, R41, R42: 4.7K; DISCRETE_R0603
R4, R10, R12, R19, R25, R46, R49, R51, R53: 0R; DISCRETE_R0603
R5, R32, R35, R37, R39: 10K/NC; DISCRETE_R0603
R6: 15K; DISCRETE_R0603
R7, R13, R14: 5.1K; DISCRETE_R0603
R8, R9, R71, R72: 22R; DISCRETE_R0603
R11: 100R; R0603
R15: 2K; DISCRETE_R0603
R16, R17, R18, R21, R23, R24, R33, R34, R36, R43, R44, R67: 10K; DISCRETE_R0603
R20: 45.3K; DISCRETE_R0603
R22: 100K; DISCRETE_R0603
R26, R38, R40: 0R; R0603
R27, R28: 47K; DISCRETE_R0603
R29: 1.8R 1%; DISCRETE_R0603
R30: 53.6K; DISCRETE_R0603
R31: 10K/NC; R0603
R45, R74, R75: 1K; DISCRETE_R0603
R47: NC/1K; DISCRETE_R0603
R48, R54, R172: 100K; R0603
R50, R52, R56: 0R/NC; DISCRETE_R0603
R55: 100k; R0603
R58: 10k; R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
U1, U3: RY3420; A_XBJ_SOT23-5
U2: ESP32-S; ESP32-S3
U4: MT9201; SOT23-6
U5: LP3318; LP3318_SOT23-5
U6: CH340C; SOP-16
U11: NS4168-ESOP-8
U26: 4054A; SOP23-5

Connections:
3V3: C2.1, C4.2, C7.2, C8.2, C9.2, C12.2, C13.1, C20.1, C26.1, C29.2, C30.2, C31.2, C32.2, C33.1, C54.2, J4.2, J4.6, J6.3, J7.3, J10.3, L4.2, P2.5 (2), P4.5 (2), Q4.2 (S), R3.2, R5.1, R10.1, R16.1, R17.1, R18.1, R20.1, R22.2, R23.1, R24.1, R41.2, R42.2, R47.2, R48.1, R56.1, R67.1, SD1.4 (VDD), U2.2 (3V3), U6.4 (V3), U6.16 (VCC)
AVDD_10V: C10.2, C15.2, C17.2, D1.2 (-), J2.P$8 (AVDD), Q1.1, R1.1
BAT+: C47.2, C48.2, D5.A, J1.P$1, Q3.3 (D), U26.3 (BAT)
D+: J3.A6 (DP1), J3.B6 (DP2), R9.1
D-: J3.A7 (DN1), J3.B7 (DN2), R8.1
DCLK1: C1.2, J2.P$14 (DCLK), R38.2
DTR: Q10.2 (E), R75.2, U6.13 (DTR#)
EN_RESET: C11.1, K4.2, Q9.3 (C), R18.2, R40.1, R46.2, R54.2, U2.3 (EN)
GND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, C14.2, C15.1, C16.2, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C29.1, C30.1, C31.1, C32.1, C33.2, C34.1, C35.1, C36.1, C37.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.2, C51.2, C54.1, D2.+, D4.-, J1.P$2, J1.P$3, J1.P$4, J2.P$3 (GND3), J2.P$13 (GND2), J2.P$15 (GND1), J2.P$16 (R0), J2.P$17 (R1), J2.P$18 (R2), J2.P$24 (G0), J2.P$25 (G1), J2.P$32 (B0), J2.P$33 (B1), J2.P$34 (B2), J2.P$46 (GND), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J4.1, J4.5, J5.P$3, J5.P$4, J6.4, J6.SS1, J6.SS2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
I2S_BCLK: R19.1, U11.3 (BCLK)
I2S_CTRL: R22.1, U11.1 (CTRL)
I2S_SDIN: R4.1, U11.4 (SDATA)
IO0_BOOT_CLK: K1.2, Q10.3 (C), R38.1, U2.27 (IO0)
IO1_G7: J2.P$31 (G7), U2.39 (IO1)
IO2_LCD_BL_CTR: R11.2, U2.38 (IO2), U4.4 (4-EN)
IO3_G4: J2.P$28 (G4), U2.15 (IO3)
IO4_B7: J2.P$39 (B7), U2.4 (IO4)
IO5_B6: J2.P$38 (B6), U2.5 (IO5)
IO6_B5: J2.P$37 (B5), U2.6 (IO6)
IO7_B4: J2.P$36 (B4), U2.7 (IO7)
IO8_G5: J2.P$29 (G5), U2.12 (IO8)
IO9_G2: J2.P$26 (G2), U2.17 (IO9)
IO10_TF_CS: R67.2, SD1.2 (CS), U2.18 (IO10)
IO11_TF_SPI_MOSI/TP_DIN: R23.2, SD1.3 (DI), U2.19 (IO11)
IO12_TF_CLK/TP_CLK: SD1.5 (SCLK), U2.20 (IO12)
IO13_TF_SPI_MISO/TP_OUT: R24.2, SD1.7 (DO), U2.21 (IO13)
IO14_R3: J2.P$19 (R3), U2.22 (IO14)
IO15_B3: J2.P$35 (B3), U2.8 (IO15)
IO16_G6: J2.P$30 (G6), U2.9 (IO16)
IO17_I2S_SDIN: R4.2, U2.10 (IO17)
IO18_I2S_LRCLK: R12.2, U2.11 (IO18)
IO19_I2C_SDA: J4.7, J6.2, P2.2 (5), P4.2 (5), R41.1, U2.13 (IO19)
IO20_I2C_SCL: J4.8, J6.1, P2.1 (6), P4.1 (6), R42.1, U2.14 (IO20)
IO21_R4: J2.P$20 (R4), U2.23 (IO21)
IO38_D: J4.4, J7.1, P2.3 (4), P4.3 (4), R5.2, U2.31 (IO38)
IO39_HSYNC: J2.P$40 (HSYNC), U2.32 (IO39)
IO40_VSYNC: J2.P$41 (VSYNC), U2.33 (IO40)
IO41_DE: J2.P$42 (DE), U2.34 (IO41)
IO42-I2S_BCLK: R19.2, U2.35 (IO42)
IO45_R7: J2.P$23 (R7), R31.2, U2.26 (IO45)
IO46_G3: J2.P$27 (G3), U2.16 (IO46)
IO47_R5: J2.P$21 (R5), U2.24 (IO47)
IO48_R6: J2.P$22 (R6), U2.25 (IO48)
L/R: J2.P$12 (L/R), R34.1, R35.2
LCD_LEDA: C19.2, C21.2, D6.2 (-), J2.P$49 (LED-A), J2.P$50 (LED_A), U4.5 (5-OV)
LCD_LEDK: J2.P$47 (LED-K), J2.P$48 (LED_K), R29.1, U4.3 (3-FB)
LRCLK: R12.1, U11.2 (LRCLK)
unnamed: LED1.+, R3.1
unnamed: J2.P$45 (VCOM), R25.2
unnamed: C14.1, C38.1, J5.P$2
unnamed: J2.P$5 (VCOM1), R26.2
unnamed: C38.2, U11.8 (VOP)
unnamed: R1.2, R2.1, U5.3 (FB)
unnamed: C39.2, U11.5 (VON)
unnamed: C27.2, C28.2, D1.1 (+), L1.2, U5.1 (LX)
unnamed: C27.1, Q1.3
unnamed: J3.A5 (CC1), R13.2
unnamed: J2.P$43 (MODE), R36.1, R37.2
unnamed: L4.1, U1.3 (SW)
unnamed: J2.P$4 (DITHB), R39.1
unnamed: C16.1, C39.1, J5.P$1
unnamed: D6.1 (+), L5.2, U4.1 (1-SW)
unnamed: J3.B5 (CC2), R14.1
unnamed: R30.2, R43.1, U3.5 (FB)
unnamed: L2.1, U3.3 (SW)
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: Q3.1 (G), R44.2, R45.1
unnamed: R15.1, U26.5 (PROG)
unnamed: Q5.1 (B), R11.1, R58.2
unnamed: C28.1, Q2.3
unnamed: R49.1, R51.2, U3.1 (EN)
unnamed: Q4.1 (G), Q6.3 (C), R48.2
unnamed: C35.2, Q1.2, R7.1
unnamed: C34.2, Q2.1, R6.1
unnamed: R52.2, R53.1, U5.4 (EN)
unnamed: Q9.1 (B), R75.1
unnamed: Q6.1 (B), R54.1, R55.2
unnamed: Q5.3 (C), Q30.1 (G), R172.2
unnamed: Q10.1 (B), R74.1
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
unnamed: R16.2, SD1.1 (DATA2)
unnamed: R17.2, SD1.8 (DATA1)
RESET: P2.6 (1), P4.6 (1), R40.2
RTS: Q9.2 (E), R74.2, U6.14 (RTS#)
TFT-3V3: C5.1, C22.2, J2.P$44 (DVDD), Q4.3 (D), R32.2, R34.2, R36.2, R39.2, R56.2
TFT_RESET: C51.1, J2.P$7 (RESET), R46.1, R47.1
U/D: J2.P$11 (U/D), R32.1, R33.2
UART0_RXD0: J10.1, R72.1, U2.36 (RXD0)
UART0_TXD0: J10.2, R71.1, U2.37 (TXD0)
USB_D+: R9.2, U6.5 (UD+)
USB_D-: R8.2, U6.6 (UD-)
VBUS: C49.2, C50.1, D3.1 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R45.2, U26.4 (VCC)
VCOM: C37.2, C44.2, C45.2, L2.2, R25.1, R26.1, R30.1
VDD: C24.1, C25.1, R10.2, R50.2, U11.6 (VDD)
VGH+18V: C40.2, D2.-, J2.P$10 (VGH), R7.2, R27.1
VGL-8.2V: C41.2, D4.+, J2.P$9 (VGL), R6.2, R28.1
VIN: C3.2, C6.2, C23.2, C36.2, C42.2, C46.2, D3.2 (-), D5.C, L1.1, Q3.2 (S), Q30.2 (S), R50.1, R51.1, R52.1, R172.1, U1.1 (EN), U1.4 (VIN), U3.4 (VIN), U5.5 (VIN)
VIN2: C18.2, C43.2, L5.1, Q30.3 (D), R49.2, R53.2, U4.6 (6-VIN)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
系统3.3V电源
UART0接口
主控 ESP32-S3-WROOM-1-N4R8
USB type-c座子
电池及控制电路
IO0: 低电平：下载启动 高电平：SPI启动
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
IIS 功放:NS4168
TF Card
BOOT
RESET
POWER LED
LCD+TP 接口
电容屏TP
Iout=0.2/R29
L/R和U/D，预留上下拉
数据传输模式选择，预留上下拉
R37/R36选DE和H/V
Vout=0.6*(R20/R21 +1)=10V
正负压源
LCD恒流驱动
默认使用右边P4的触摸接口，如需更换使用左边P2触摸接口,BOM需要更改使用P2
默认使用右边P4的触摸接口，如需更换使用左边P2触摸接口,PCB的排线孔也要更改
HM3416H更换为RY3420
VCOM=0.6*(R20/R21 +1)=3.8V
500mA
BAT

Board: 2 copper layers, 181.1 x 103.9 mm, 159 parts (1 on the bottom side), 99 nets.

Other parts of the board:
U$10: 7.0底框
U$15: 7.0板框
U$30: ELECROW-NEW

## Commit log (part)

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2026-01-19 Fix MIDISerial undefined error for UART0 build
2026-01-19 modified: README.md renamed: BUILD_VERIFICATION.md -> docs/BUILD_VERIFICATION.md renamed: CHANGELOG.md -> docs/CHANGELOG.md renamed: DRAM_FIX_EXPLANATION.md -> docs/DRAM_FIX_EXPLANATION.md renamed: P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
2026-01-19 "Can we fix it? Yes we can" - Bob the Build process. Removed all the cruddy errors when building. Much tidier now.
2026-01-19 cyd35 is groovy
2026-01-26 gui updates and fixes
2026-02-03 Implement hardware timer-based MIDI clock for precise timing
2026-02-03 Re-add requestRedraw for clock-synced UI animations
2026-02-03 Add comprehensive implementation summary document
2026-02-03 Fix MIDI clock timing accuracy with microsecond accumulator
2026-02-03 Fix MIDI clock timing with microsecond accumulator (working solution)
2026-02-03 Integrate uClock library with proper API usage (verified syntax)
2026-02-03 Update documentation with correct uClock v2.3.0 API
2026-02-03 Fix MIDI clock timing with microsecond accumulator (no external libs)
2026-02-03 Integrate uClock library from julesdg6 fork for ESP32 Core 6.10.0 support
2026-02-03 Add complete solution summary for uClock integration
2026-02-03 modified: src/clock_manager.cpp
2026-02-03 Implement uClock step sequencer extension for all sequencer/generative modules
2026-02-03 Add TB3PO interface documentation
2026-02-03 Add comprehensive documentation for uClock step sequencer implementation
2026-02-03 Update TB3PO_INTERFACE.md documentation with layout changes
2026-02-03 Add documentation for splash screen signature fix
2026-02-03 Final code review fixes: use text_static and fix canvas allocation order
2026-02-03 Fix board naming: rename 4832S040R to 3248S040R (WIDTH×HEIGHT convention)
2026-02-03 Fix compilation errors: initialize render layer before splash and fix C++17 warnings
2026-02-04 Fix TB-3PO MIDI note on/off handling with slide support, fix Raga time-based scheduling
2026-02-05 some fixes
2026-02-05 Fix GT911 I2C clock flag to match ESP-IDF typo (NOMAL not NORMAL)
2026-02-05 Fix modes not playing: don't clear step counters on start
2026-02-05 Remove unused ISR callbacks from modules using consumeReadySteps
2026-02-05 Fix GitHub release creation by adding contents:write permission and fix discord workflow
2026-02-05 Add CHANGELOG extraction to release workflow
2026-02-05 Add BLE Serial service implementation with dual BLE support
2026-02-05 Add BLE Serial environment to build workflow
2026-02-05 Fix spelling: ppqn -> PPQN in documentation
2026-02-05 Add testing guide and update CHANGELOG for BLE Serial feature
2026-02-05 platformio: fix BOARD_NAME quoting for ble-serial env
2026-02-05 Add issue drafts for deeper fixes
2026-02-05 Force rebuild of assets_splash.cpp to ensure linker picks up correct symbol
2026-02-05 Remove BLE Serial implementation files and references
    The BLE Serial feature was causing library compilation errors because
    the source files were being compiled unconditionally, even though the
    feature was disabled. Since BLE Serial has been marked as unreliable
    and disabled, removing all related files to prevent build issues.
    Removed:
    - include/ble_serial.h
2026-02-05 Fix build failure: Disable USB MIDI for standard ESP32, only enable for ESP32-S3
2026-02-05 Fix code review issues: correct job filter logic and parent issue handling
2026-02-05 Add implementation summary for CI failure reporting
2026-02-05 Move MIN_SAFE_BPM constant to file scope for better visibility
2026-02-05 Fix ISR safety and tick handling in clock_manager
2026-02-05 Address code review feedback: improve tick processing logic and comments
2026-02-05 Refactor tick processing loop for better clarity and eliminate duplicate locking
2026-02-05 Fix triplet timing helper usage and persistent accumulator
    - Move tripletAccumulator from static local variable to EuclideanState struct
    - Initialize tripletAccumulator in initializeEuclideanMode() and on playback start
    - Use getEuclideanStepIntervalTicks() helper in updateEuclideanSequencer()
    - This ensures proper timing reset when switching modes or re-entering Euclidean mode
    Fixes #117
2026-02-05 Add comprehensive UI update analysis document
2026-02-05 Complete UI update documentation suite with summary and updated docs README
2026-02-05 Update MORPH module UI - reorganize layout and improve readability
2026-02-05 Update RNG JAMS module UI - consolidate controls, add interactive slider, improve layout
2026-02-05 Update TB-3PO module UI - group SEED/REGEN controls, improve density layout
2026-02-05 Update EUCLID module UI - move circle left, consolidate BPM, larger time division
2026-02-05 Update release types for Discord notification workflow
2026-02-06 Add ESP Web Tools integration for browser-based firmware flashing
2026-02-06 Add implementation summary document
2026-02-06 Add comprehensive documentation for Web Debug Console
2026-02-06 Add visual guide for Web Debug Console interface
2026-02-06 Add comprehensive public release summary document
2026-02-06 Add v0.1.0 release preparation notes
2026-02-07 Add GitHub Pages setup instructions
2026-02-07 Fix Discord release notifications to include release notes
    Replace releasify-action with custom Discord webhook integration that properly extracts and sends the release body content from GitHub releases. This fixes the "No release notes provided" issue.
2026-02-07 Update debug console UI: rename to aCYD-MIDI and change to side-by-side layout
2026-02-07 Add guide for updating AI costs with actual billing data
2026-02-07 Fix layout: top 1/3 = 303 panel, bottom 2/3 split (serial left, MIDI right)
2026-02-07 Deploy debug console 5898f76f7c8b16e53562e84ed675c27ae91959f0
2026-02-07 Deploy web installer for v0.1.0 448f3380c0d8c8d70dd89716da6c610d560131e7
2026-02-07 Fix Discord notification workflow - properly escape release body
2026-02-07 Add Discord notifications troubleshooting guide
2026-02-07 Improve code clarity with constants and better documentation
2026-02-07 Deploy web installer for v0.1.1 fb9fbd00ce1f879f41d762699074c4d20a0726eb
2026-02-07 Fix debug console link path in index.html
    - Changed from ../debug-console/ to ./debug-console/
    - The relative path was going up one directory incorrectly
    - Now correctly points to debug-console subdirectory on GitHub Pages
2026-02-07 Deploy web installer for v0.1.2 2904ceeee0ddf638d4d79aafc75a3184b1c13410
2026-02-07 Fix script path in debug-console/index.html for GitHub Pages deployment
2026-02-07 Add automatic GitHub Pages deployment on main branch pushes
2026-02-07 Add critical GitHub Pages configuration guide
2026-02-08 Add Elecrow ESP32 7" display board support
2026-02-08 Fix missing upload_speed in elecrow-esp32-7_0-uart0 environment
2026-02-08 Deploy web installer from main branch - commit fb40573f18d59b7fc2fed40d3f87937a66527c86 fb40573f18d59b7fc2fed40d3f87937a66527c86
2026-02-08 Deploy web installer from main branch - commit 341b2e2a49cb7b5fbd458e197953c6824dbf2a74 341b2e2a49cb7b5fbd458e197953c6824dbf2a74
2026-02-08 chore(release): v0.1.4 — add Elecrow 7" support
2026-02-08 Deploy web installer from main branch - commit 979a1a5f6e07d7aa82f13e24cdceed9d465022b4 979a1a5f6e07d7aa82f13e24cdceed9d465022b4
2026-02-09 Implement web debug console improvements - remove keyboard, add synth, unified log panel
2026-02-09 Address code review feedback - improve type safety and add clarifying comments
2026-02-09 The morph commit
2026-02-09 Add screenshot button to settings menu with board and version in filename
2026-02-09 Remove BPM controls from all module panels
2026-02-09 Address code review feedback - fix magic numbers and previousMode capture
2026-02-09 Extract BPM display area calculation and add documentation
2026-02-09 Fix static variable scope and improve code clarity
2026-02-09 Fix icon parameter and knob tracking across page switches
2026-02-09 Add DEG_TO_RAD constant and enhance documentation
2026-02-09 Fix DEG_TO_RAD conflict with Arduino.h macro
2026-02-09 Fix duplicate kModeCount definition
2026-02-10 Add Fractal Note Echo mode implementation
2026-02-10 Add implementation documentation for Fractal Echo
2026-02-10 Add quick start guide for Fractal Echo
2026-02-10 Fix conditional compilation guards and add documentation
2026-02-10 Add implementation summary documentation
2026-02-10 Implement title bar improvements with BPM button and transport controls
    - Modified drawHeader to left-justify title and add dividing line after back button
    - Removed subtitle display from header
    - Added font auto-scaling based on display resolution
    - Converted BPM display to a proper button (right-justified to status indicators)
    - Added transport controls (PLAY/STOP) to BPM settings dialog
    - Increased BPM dialog height to accommodate transport controls
2026-02-10 Address additional code review feedback
    - Added bounds checking to prevent BPM button from going off-screen
    - Improved comment accuracy about display scaling reference values
    - Clarified that transport buttons remain interactive regardless of state
    - Enhanced code robustness and documentation
2026-02-10 Deploy web installer from main branch - commit 01bc499885eb1dc1d448a5d191ee612780e69198 01bc499885eb1dc1d448a5d191ee612780e69198
2026-02-10 Add enhanced UI with parameter controls and documentation
2026-02-10 Add Baby8 software emulation infrastructure and core implementation
2026-02-10 Add Baby8 documentation and README updates
2026-02-10 Deploy web installer from main branch - commit aac03d54eeb711160cc2cfa39190df90fe80646e aac03d54eeb711160cc2cfa39190df90fe80646e
2026-02-10 fixing docs
2026-02-10 Fix duplicate FRACTAL_ECHO enum value from merge conflict
2026-02-10 Deploy web installer from main branch - commit 49d5dbb7b8cf3c80eb01443580b6719554868633 49d5dbb7b8cf3c80eb01443580b6719554868633
2026-02-10 Prepare release v0.1.5
2026-02-10 Fix menu issues: enable Baby8, disable 8ENC, update experimental menu
2026-02-10 Implement 2nd-order Markov chain for Raga Bhairavi
2026-02-10 Integrate framework with existing code and add reference module
2026-02-10 Add implementation summary and finalize framework
2026-02-11 Remove incompatible setTextSize calls from Baby8 mode
2026-02-11 Prepare release v0.1.6
2026-02-11 Add comprehensive screenshot capture with all mode states
2026-02-11 Address code review feedback - reduce MAX_DOCS, use tolower(), add timestamp
2026-02-15 Deploy web installer from main branch - commit 2507dd695b31afc9aa03924604720f733d355586 2507dd695b31afc9aa03924604720f733d355586
2026-02-15 Deploy web installer from main branch - commit 7b81bea3e9fa0012bc5b82687ab5a3a65590f275 7b81bea3e9fa0012bc5b82687ab5a3a65590f275
2026-02-15 Implement core data structures and generator for world music system
2026-02-15 Fix stack buffer size and clarify comment per code review
2026-04-18 Add slot performer mode with configurable slot count and quantized looper recording
    Agent-Logs-Url: https://github.com/julesdg6/aCYD-MIDI/sessions/ae501835-8a96-401f-9a25-5d19cac46280
2026-04-18 Polish slot performer arithmetic safety and constants
    Agent-Logs-Url: https://github.com/julesdg6/aCYD-MIDI/sessions/ae501835-8a96-401f-9a25-5d19cac46280
2026-04-20 Harden CI fix for slot label rendering compatibility
    Agent-Logs-Url: https://github.com/julesdg6/aCYD-MIDI/sessions/6dd31c86-e0ba-415f-b401-270a1859bdcb
2026-04-20 fix: harden BLE setup path against null pointer crashes
    Agent-Logs-Url: https://github.com/julesdg6/aCYD-MIDI/sessions/874b9468-0d76-4eba-9e55-f606927814ca
2026-04-20 Deploy web installer from main branch - commit 9346ea22add3a8c565ee305543cd59ac6a1147ef 9346ea22add3a8c565ee305543cd59ac6a1147ef
2026-04-20 feat: add zynthian kpnum keypad emulator mode
    Agent-Logs-Url: https://github.com/julesdg6/aCYD-MIDI/sessions/3a3513f9-1127-46af-a8f4-8f2ef3136b53
2026-04-20 Deploy web installer from main branch - commit d3730dad299299da0e95f3dec8e563735d3f3c5c d3730dad299299da0e95f3dec8e563735d3f3c5c

Notices in the files:
README.md:
License:
MIT License - see [LICENSE](LICENSE) for full terms.
License: MIT
